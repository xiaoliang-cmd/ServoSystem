# Keil uVision project ServoSystem.uvprojx, settings and files
target ServoSystem (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ServoSystem +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\STM32F10x_StdPeriph_Driver\inc;..\SYSTEM\delay;..\SYSTEM\usart;..\AP\LED;..\SYSTEM\sys;..\SYSTEM\timer;..\SYSTEM\key;..\SYSTEM\exti;..\SYSTEM\RS485;..\SYSTEM\control
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c
  group STM32F10x_StdPeriph_Driver
    ../STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CORE
    ../CORE/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h stm32f10x_conf.h
  group startup
    ../CORE/: startup_stm32f10x_md.s
  group AP
    ../AP/LED/: led.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.h
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/timer/: timer.c
    ../SYSTEM/key/: key.c
    ../SYSTEM/exti/: exti.c
    ../SYSTEM/RS485/: rs485.c
    ../SYSTEM/control/: control.c
